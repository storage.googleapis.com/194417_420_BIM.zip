Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T19:06:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 19:06:33 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\aebcf6de-5951-448e-8904-1f8d6e78b1ba\ifc * Database version: 5507 * Database creation date: Fri Apr 26 19:06:32 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 19:06:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 19:06:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 420 Shower set, Bluetooth, 420:420 Shower set, Bluetooth:88753
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 146.113 mm; NominalHeight: 781.71 mm; NominalWidth: 434.646 mm
Type - Electrical - Bluetooth: 4.x (D054404); Operating Voltage: 0 V; Protection Class: IP X7
Type - General - Author: BIMStone; BIMObjectName: 420; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 7.35; CO2 Emissions (A4): 0.31; CO2 Emissions (C2): 0.01; CO2 Emissions (C3): 0; CO2 Emissions (C4): 1.96; CO2 Emissions (D): -0.81; EAN Number: 6414150103506; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 1112 ,ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; LVI Number: 6510308; NRF Number: 4205524; RSK Number: 8320415; Sales Package dimensions (LxWxH): 780 x 156 x 79; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/420; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/189365_Oras_EPD_Shower_set_2022_06_29.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/184560_420_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/420; VVS Number: 737595504
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/420; 3D View: https://static.oras.com/AR/420; Catalog Drawing URL: http://static.oras.com/catdrw/420; Dimension Drawing URL: http://static.oras.com/dimdrw/420; FDV Document URL: http://www.oras.com/datasheet/420/en/fdv; Group: Shower set; Installation and Maintenance Guide URL: http://static.oras.com/manual/420; Interactive AR View URL: https://static.oras.com/AR/420; Long Marketing: Oras Hydractiva Digital shower set including digital hand shower with limescale protection technology, adjustable max 720 mm shower rail, wall bracket and a 1750 mm shower hose. Digital hand shower is designed to help you save water – with little effort. Save up to 22% in water and energy consumption with Oras Hydractiva Digital hand shower. By connecting the hand shower to the Digital Hand Shower App, you can set water consumption goals, receive data on your long-term usage, and to access tips on saving water. - Integrated display provides insights on total water and energy consumptions - Powered by water flow – no batteries required - Simple to attach – fits to all standard showers; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/420; Model: 420 Shower set, Bluetooth; Name_en: 420 Shower set, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 420; Product Family: Oras Hydractiva Digital; Product Image URL: http://static.oras.com/image/420; Product URL: http://static.oras.com/420; Spare-Part Information URL: http://static.oras.com/sp/420; Technical DataSheet URL: http://www.oras.com/datasheet/420/en; Type Name: 420 Shower set, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Additional Features: Display with real time feedback about the water and energy consumption.; Electronic Parts: Light indicated function(s); Installation Type: Wall mounted; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower holder;Anti limescale technology (easy to clean);Shower hose (1750 mm); Shower Spray: Sensitive; Shower Spray Number: 1 shower spray; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 420; Features: Self-powered;Bluetooth®; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 420; Name: 420 Shower set, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 435x145x780 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.517492 m2; Volume: 0.0496443 m3
Identity Data - Mark: 39
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 420: 420 Shower set, Bluetooth; Family and Type: 420: 420 Shower set, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 420: 420 Shower set, Bluetooth; Type Id: 420: 420 Shower set, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
